# Keil uVision project project.uvprojx, settings and files
target RT-Thread TM4C129X (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C129EKCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-tm4c
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C129EKCPDT
  c include: applications;.;drivers;libraries;libraries\inc;libraries\driverlib;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: tm4c_rom.sct
  group Applications
    applications/: application.c board.c startup.c
    ./applications/: ringbuffer.c uart_app.c time_app.c
  group Libraries
    libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c tiva_timer.c uart.c udma.c usb.c watchdog.c
    libraries/startup/: startup_rvmdk.S
  group Kernel
    ../../src/: clock.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
